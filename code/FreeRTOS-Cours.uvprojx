# Keil uVision project FreeRTOS-Cours.uvprojx, settings and files
target FreeRTOS-Cours (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS-Cours
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .;.\FreeRTOS-Source\include;.\FreeRTOS-Source\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./: startup_MPS_CM3.s
  group Cours ISEN
    ./: simulateur.h simulateur.c main.c FreeRTOSConfig.h
  group FreeRTOS-Source
    ./FreeRTOS-Source/: tasks.c list.c queue.c
    ./FreeRTOS-Source/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS-Source/portable/MemMang/: heap_1.c
